Commit message: tiene las funciones para stats de fuerzas

File: solo12-pybullet/Models/ladrillos.urdf (robot description, URDF)
Before this commit: robot obstacle, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.1 0.2 0.05; visual box size=0.1 0.2 0.05
